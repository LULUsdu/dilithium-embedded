# Keil uVision project Blinky.uvprojx, settings and files
target Simulation (6210000::V6.21::ARMCLANG)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: Blinky +hex
  c flags: OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: BLINKY_KEYGEN_ONLY
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\RTE\Device\ARMCM0\ARMCM0_EVR_UNINIT_ac6.sct
  group Source Files
    ./: Blinky.c randombytes.c sign.c packing.c polyvec.c poly.c poly_mul_12289.c table12289.c ntt.c reduce.c rounding.c fips202.c symmetric-shake.c keccakf1600_opt.s ntt_dilithium_m0_abi_test.s modmul_q8380417_preComputeB_Cortex-M0-M3.s ntt_dilithium_m0.s poly_pointwise_montgomery_m0.s NTT_forward12289new2.s NTT_backward12289new3.s pairMul12289new2.s stack_measure_m0.s
    ./tests/: poly_pointwise_montgomery_asm_test.c invntt_specialized_validation.c dilithium_specialized_regression.c asm12289_baseline.c pairMul12289new2_opt.s NTT_backward12289new3_opt.s invntt12289_opt_stage1.c
  group Documentation
    ./: Abstract.txt
target Simulation_ManualTest (6210000::V6.21::ARMCLANG)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: as above
  output: Blinky_ManualTest +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: BLINKY_KEYGEN_ONLY,BLINKY_MEMORY_MEASURE
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\RTE\Device\ARMCM0\ARMCM0_EVR_UNINIT_ac6.sct
software components: CMSIS:CORE 5.6.0, CMSIS:RTOS2:Keil RTX5 5.5.4, Device:Startup 2.0.3, Compiler:Event Recorder 1.5.1, Compiler:I/O:STDOUT 1.2.0
